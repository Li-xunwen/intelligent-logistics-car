# Keil uVision project BordCtrl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: BordCtrl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c IIC.c IIC.h IAP.c IAP.h PWM.c PWM.h DRIVES.c DRIVES.h
